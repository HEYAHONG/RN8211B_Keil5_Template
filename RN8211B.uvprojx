# Keil uVision project RN8211B.uvprojx, settings and files
target RN8211B (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: RN8211B Rerengy
  pack: Rerengy.RN8211B_DFP.1.0.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: RN8211B
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\CMSIS\core;.\FreeRTOS\FreeRTOS-Kernel\include;.\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM0;.\FreeRTOS\FreeRTOS-Port
  asm include: .\FreeRTOS\FreeRTOS-Port
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group CMSIS
    ./CMSIS/: RN8211.h startup_RN8211.s system_RN8211.c system_RN8211.h
    ./CMSIS/core/: core_cm0.c core_cm0.h core_cmFunc.h core_cmInstr.h
  group main
    ./: main.c
  group FreeRTOS
    ./FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM0/: port.c
    ./FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group FreeRTOS-Port
    ./FreeRTOS/FreeRTOS-Port/: freertos.c FreeRTOSConfig.h
